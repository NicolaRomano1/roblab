Commit message: Update smartsix.urdf

File: fanuc_description/robot/smartsix.urdf (robot description, URDF)
Before this commit: robot smartsix, 8 links, 7 joints
Joints:
- joint joint2: origin xyz=0.15 0 0.525 rpy=-1.5708 0 0 -> xyz=0.15 0 0.525 rpy=-1.5708 -1.5708 0
